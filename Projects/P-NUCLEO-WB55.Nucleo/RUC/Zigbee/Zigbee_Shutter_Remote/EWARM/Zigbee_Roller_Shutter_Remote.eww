<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_Roller_Shutter_Remote.ewp</path>
    </project>
    <batchBuild />
</workspace>
