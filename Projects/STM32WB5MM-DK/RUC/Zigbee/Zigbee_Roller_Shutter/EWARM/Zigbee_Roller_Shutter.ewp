# IAR project Zigbee_Roller_Shutter.ewp, settings and files
configuration Zigbee_Roller_Shutter (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55MMG ST STM32WB55MMG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx; USE_STM32WB5M_DK; ZIGBEE_WB
  ICCARM.IExtraOptions: --diag_suppress Pe111; --diag_suppress Pe188
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../STM32_WPAN/App/app_roller_shutter; ../STM32_WPAN/App/app_light; ../../../../../../Drivers/BSP/AMS_Rev3/Inc; ../../../../../../Drivers/BSP/blinkt; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/inc; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/mac; ../../../../../../Drivers/BSP/STM32WB5MM-DK; ../../../../../../Drivers/BSP/Components/ssd1315; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/LCD; ../../../../../../Utilities/Fonts
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Zigbee_Roller_Shutter.bin
  ILINK.IlinkOutputFile: Zigbee_Roller_Shutter.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_entry.c app_menu.c ee.c flash_driver.c hw_flash.c app_nvm.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c stm_logging.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_core.c app_menu_cfg.c app_zigbee.c
  group Application/User/STM32_WPAN/App/Window_Endpoint
    ../STM32_WPAN/App/app_roller_shutter/: app_roller_shutter.c app_roller_shutter_window_covering.c app_roller_shutter_occupancy.c
  group Application/User/STM32_WPAN/App/Light_Endpoint
    ../STM32_WPAN/App/app_light/: app_light.c app_light_onoff.c app_light_level.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
    ../../../../../../Drivers/BSP/blinkt/: blinkt.c
  group Drivers/BSP/AMS
    ../../../../../../Drivers/BSP/AMS_Rev3/Src/: AMS.c AMS_ADC.c AMS_PWM.c
  group Drivers/BSP/STM32WB5MM-DK
    ../../../../../../Drivers/BSP/STM32WB5MM-DK/: stm32wb5mm_dk.c stm32wb5mm_dk_bus.c stm32wb5mm_dk_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/schi
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_zigbee_hci.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Middlewares/STM32_WPAN/zigbee/core
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/src/: zigbee_core_wb.c
  group Middlewares/STM32_WPAN/zigbee/stack
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/lib/: stm32wb_zigbee_wb_lib.a
  group Utilities/LCD
    ../../../../../../Utilities/LCD/: stm32_lcd.c
  group Utilities/lpm/tiny_lpm
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Utilities/sequencer
    ../../../../../../Utilities/sequencer/: stm32_seq.c
